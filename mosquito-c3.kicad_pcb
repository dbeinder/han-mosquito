# Repository dbeinder/han-mosquito

File README.md:

# µHAN mosquito

> **_Aus Österreich?:_** Ich habe noch einige Module übrig, bei Interesse bitte Email an david(at)beinder.at
> 
>  Inkl. Versand 37€ für 1 Stk, dann +15€ für jedes weitere. Privatverkauf, Bastellösung, keine Gewährleistung, etc ;)

A tiny [M-BUS](https://m-bus.com/documentation-wired/04-physical-layer)-powered [ESP32-C3](https://www.espressif.com/sites/default/files/documentation/esp32-c3_datasheet_en.pdf) board to capture data from digital electricity meters. Compatible with [AMS reader](https://github.com/UtilitechAS/amsreader-firmware) firmware.

  - Power & flashing via USB-C
  - Power & meter signal via M-BUS (RJ11)
    - Input current limited to 40mA, this is probably only compatible with Kaifa meters
    - Firmware needs no aggressive WiFi power management, there is enough for AP mode and OTA firmware upgrade
  - ESP32-C3-MINI-1 module: 160MHz RISC-V core, 4MB Flash, 400kB RAM, 2.4GHz WiFi
  - 1mm² RGB LED
  - Two side-mounted buttons
    - Top: ESP32 reset
    - Bottom: AP mode, hold during reset to flash
  - Mounted by magnet on the IR port
  - Tested on an Austrian (Vbg) Kaifa MA309M
  - Designed in KiCad 7
  
License: free to use and modify for non-commercial use

###  Prototype pictures
  
|   |  |
| ------------- | ------------- |
|   | |

## KiCad design mosquito-c3.kicad_pcb

Parts:
C1: 150u; C_Radial_D6.3mm_H7.0mm_P2.50mm; Voltage 35V
C2, C3: 10u; C_0603_1608Metric; Voltage 35V
C4, C5: 22u; C_0603_1608Metric; Voltage 16V
C6, C7, C9: 100n; C_0402_1005Metric; Voltage 50V
C8: 2.2u; C_0402_1005Metric; Voltage 35V
D1: AL5809-40S1-7; D_SOD-123
D2, D3, D4, D5: MSK4005; D_SOD-523
D6: 6V8; D_SOD-523
D7: FC-B1010RGBT-HG; LED_0404
J1: RJ12; EVERCOM-5303-6P6C
J2: USB_C_Receptacle_USB2.0; TYPE-C-31-M-19
L1: 6.8uH; CKST252012
Q1: MMBT3906T; SOT-523
R1: 75k; R_0402_1005Metric
R2: 24k; R_0402_1005Metric
R3, R7, R8: 1M; R_0402_1005Metric
R4: 330R; R_0402_1005Metric
R5: 2.2k; R_0402_1005Metric
R6: 1k; R_0402_1005Metric
R9, R12: 200k; R_0402_1005Metric
R10, R11: 5.1k; R_0402_1005Metric
SW1, SW2: SW_Push; GT-TC018A
TP1: RX; TestPoint_Pad_D1.0mm
TP2: TX; TestPoint_Pad_D1.0mm
TP3: GND; TestPoint_Pad_D1.0mm
U1: ESP32-C3-MINI-1
U2: TP6841S6; SOT-23-6

Connections:
+3V3: C4.2, C5.2, D7.1 (A), L1.2, R1.1, R12.1, U1.3 (3V3), U1.5 (GPIO2/ADC1_CH2), U1.22 (GPIO8)
/HAN_SIGNAL: R8.2, R9.1, U1.21 (GPIO7)
/LED_B: R6.1, U1.18 (GPIO4/ADC1_CH4)
/LED_G: R5.1, U1.20 (GPIO6)
/LED_R: R4.1, U1.19 (GPIO5/ADC2_CH0)
/MBUS+: D1.2, D5.2 (A), D6.2 (A), J1.4
/SW_BOOT: SW2.2, U1.23 (GPIO9)
/SW_RESET: C9.2, R12.2, SW1.2, U1.8 (EN/CHIP_PU)
/USB_N: J2.A7 (D-), J2.B7 (D-), U1.26 (GPIO18/USB_D-)
/USB_P: J2.A6 (D+), J2.B6 (D+), U1.27 (GPIO19/USB_D+)
/USB_VBUS: D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
/V_FB: R1.2, R2.1, U2.3 (FB)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, D4.2 (A), J1.3, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R2.2, R9.2, R10.2, R11.2, SW1.1, SW2.1, TP3.1, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.2 (GND)
unnamed: C1.1, C2.2, C3.2, D2.1 (K), D3.1 (K), R3.2, U2.5 (VIN)
unnamed: D1.1, D3.2 (A)
unnamed: C6.2, D4.1 (K), L1.1, U2.6 (SW)
unnamed: C8.2, D5.1 (K), Q1.2 (E)
unnamed: D6.1 (K), R7.1
unnamed: D7.4 (BK), R6.2
unnamed: D7.3 (GK), R5.2
unnamed: D7.2 (RK), R4.2
unnamed: J2.A5 (CC1), R10.1
unnamed: J2.B5 (CC2), R11.1
unnamed: Q1.1 (B), R7.2
unnamed: Q1.3 (C), R8.1
unnamed: TP1.1, U1.30 (GPIO20/U0RXD)
unnamed: TP2.1, U1.31 (GPIO21/U0TXD)
unnamed: C6.1, U2.1 (BOOST)
unnamed: C7.2, R3.1, U2.4 (EN)

Notes on the sheet:
Alternative Buck ICs: PL88104 TP6130S6 BL9342 (needs D4) MD8941 (needs D4) LM2842 (needs D4)
has internal pullup
experimentally determined for visually equal brightness
DC/DC efficiency: @ 27V: 80% 30mA @ 27V => 250mA @ 3.3V continuous ESP32 peak current @ 3.3V: ~500mA C1: 150µF, energy from 27V to 5V: 53mJ 53mJ => additional 250mA @ 3.3V for 50ms
V_{FB}=0.8V with 1% resistors V_{out}=V_{FB}(1+R1/R2)=3.3V±6mV
derated 2x 10µF
24V: 0.7µA 36V: 2.7µA sinking a few µA into the ESP32 protection diodes is fine
40mA => 0.15s / 27V 30mA => 0.20s / 27V 20mA => 0.30s / 27V
Datasheet: R: 5mA / 274R G: 2mA / 385R B: 2mA / 335R
1.9A I_{sat}
derated 2x 1µF
RC = 0.1s
derated 150nF
would be nicer to use two resistors here great footgun for the SW developer ¯\_(ツ)_/¯
RC = 20ms

Board: 4 copper layers, 19.5 x 31.0 mm, 39 parts (3 on the bottom side), 29 nets.

File doc/bom.xlsx:

Description | LCSC | Package | Name | Designator |  | $/pcs | pcs | $ |  | JLCPCB Extended Part | THT
5303-6P6C | C3097718 |  | RJ11 connector | J1 |  | 7.1999999999999995E-2 | 1 | 7.1999999999999995E-2 |  | 1 | 1
U264-141N-4BAC10 | C692526 |  | USB-C connector | J2 |  | 0.74919999999999998 | 1 | 0.74919999999999998 |  | 1 | 1
GT-TC018A-H035-L1 | C778153 |  | side NO switch | SW1, SW2 |  | 2.9100000000000001E-2 | 2 | 5.8200000000000002E-2 |  | 1
ESP32-C3-MINI-1-H4 | C2934569 |  | ESP32-C3 module | U1 |  | 2.1063000000000001 | 1 | 2.1063000000000001 |  | 1
TP6841S6 | C2844736 | SOT-23-6 | DC/DC, 800kHz | U2 |  | 0.41689999999999999 | 1 | 0.41689999999999999 |  | 1
MSK4010 | C345958 | SOD-523 | schottky | D2, D3, D5 |  | 2.9499999999999998E-2 | 3 | 8.8499999999999995E-2 |  | 1
BZX584C6V8 | C83014 | SOD-523 | zener 6V2 | D6 |  | 2.6800000000000001E-2 | 1 | 2.6800000000000001E-2 |  | 1
FC-B1010RGBT-HG | C158099 | 0404 | RGB LED | D7 |  | 1.9199999999999998E-2 | 1 | 1.9199999999999998E-2 |  | 1
AL5809-40S1-7 | C151420 | SOD-123 | diode driver 40mA | D1 |  | 0.50309999999999999 | 1 | 0.50309999999999999 |  | 1
MMBT3906T | C61615 | SOT-523-3 | PNP | Q1 |  | 2.4E-2 | 1 | 2.4E-2 |  | 1
NPXC0901V151MF | C2976307 |  | 150uF 35V D6.3mm, H7mm | C1 |  | 0.16400000000000001 | 1 | 0.16400000000000001 |  | 1 | 1
CL10A226MO7JZNC | C2762594 | 0402 | 22uF, 16V | C4, C5 |  | 5.4300000000000001E-2 | 2 | 0.1086 |  | 1
GRM188R6YA106MA73D | C194427 | 0402 | 10uF, 35V | C2, C3 |  | 3.6999999999999998E-2 | 2 | 7.3999999999999996E-2 |  | 1
CL05B104KB54PNC | C307331 | 0402 | 100nF, 50V | C6, C7, C9 |  | 3.0999999999999999E-3 | 3 | 9.2999999999999992E-3 |  | 0
GRM155R6YA225KE11D | C237392 | 0402 | 2.2uF, 35V | C8 |  | 4.1700000000000001E-2 | 1 | 4.1700000000000001E-2 |  | 1
CKST252012-6.8uH/M | C3002554 | 252012 | 6.8uH | L1 |  | 6.0900000000000003E-2 | 1 | 6.0900000000000003E-2 |  | 1
0402WGF7502TCE | C25798 | 0402 | 75k, 1% | R1 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0
0402WGF2402TCE | C25769 | 0402 | 24k, 1% | R2 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0
0402WGF1004TCE | C26083 | 0402 | 1M, 1% | R3, R7, R8 |  | 5.0000000000000001E-4 | 3 | 1.5E-3 |  | 0
0402WGF3300TCE | C25104 | 0402 | 330R, 1% | R4 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0
0402WGF2201TCE | C25879 | 0402 | 2.2k, 1% | R5 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0
0402WGF1001TCE | C11702 | 0402 | 1k, 1% | R6 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0
0402WGF2003TCE | C25764 | 0402 | 200k, 1% | R9, R12 |  | 5.0000000000000001E-4 | 2 | 1E-3 |  | 0
0402WGF5101TCE | C25905 | 0402 | 5.1k, 1% | R10, R11 |  | 5.0000000000000001E-4 | 1 | 5.0000000000000001E-4 |  | 0

## Commit log

2023-03-17 initial version
2023-03-19 pcb cleanup
2023-03-24 add KiKit tab/panel hints
2023-03-24 add 4x3 panel
